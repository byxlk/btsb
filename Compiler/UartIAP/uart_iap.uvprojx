# Keil uVision project uart_iap.uvprojx, settings and files
target UartIAP (ARM-ADS)
  device: STM32F205RCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart_iap
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
