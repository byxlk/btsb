# Keil uVision project Q-SYS.uvprojx, settings and files
target Q-SYS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Q-SYS +hex
  c flags: v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Drivers\Lib;..\Drivers\Lib\inc;..\Q_Sys_Core;..\Drivers;..\Q_Sys_Core\Pages;..\Q_Sys_Core\Resources;..\FatFS;..\uCos;..\uCos\Cpu;..\uCos\Ports;..\uCos\Lib;..\Q_Sys_Core\Q_Gui;..\Q_Sys_Core\Q_Heap;..\Drivers\UsbLib\inc;..\Drivers\Usb\inc;..\Q_Sys_Core\Q_Web;..\Q_Sys_Core\CtrlObj;..\Os_Wrap;..\FreeRTOS\include;..\FreeRTOS\portable;..\Q_Sys_Core\Q_Database;..\Q_Sys_Core\Q_Music;..\Q_Sys_Core\Q_Shell
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ../Start/: main.c STM32F10x.s
  group Lib
    ../Drivers/Lib/: core_cm3.c stm32f10x_it.c
    ../Drivers/Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_spi.c
  group Drivers
    ../Drivers/: Adc.c CC2500.c Lcd_HX8312.c Lcd_ILI9320.c Rtc.c SdCard.c Spi.c SpiFlash.c SpiTouch.c Time.c Uart.c Vs1003b.c
    ../Drivers/Usb/src/: usb_desc.c usb_endp.c usb_hw_config.c usb_istr.c usb_prop.c usb_pwr.c
  group UsbLib
    ../Drivers/UsbLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c
    ../FreeRTOS/portable/: port.c
  group uCos
    ../uCos/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../uCos/Ports/: os_cpu_c.c os_cpu_a.asm
    ../uCos/Cpu/: cpu_c.c cpu_a.asm
  group OS_Wrap
    ../Os_Wrap/: Os_Wrap.c Os_Select.h
  group FatFs
    ../FatFS/: diskio.c ff.c FsWrap.c
    ../FatFS/option/: cc936.c
  group System
    ../Q_Sys_Core/: InputHandler.c KeyHandler.c MiscHandler.c PublicFunc.c SyncHandler.c SystemInit.c Theme.c TouchHandler.c UserApi.c
    ../Q_Sys_Core/Q_Heap/: Q_Heap.c
    ../Q_Sys_Core/CtrlObj/: ControlObj.c
    ../Q_Sys_Core/Q_Gui/: Q_Gui.c
    ../Q_Sys_Core/Q_Music/: MusicHandler.c
    ../Q_Sys_Core/Q_Database/: Q_Database.c
    ../Q_Sys_Core/Q_Shell/: Q_Shell.c
  group Resources
    ../Q_Sys_Core/Resources/: CtrlObjImg.c Resources.c
  group Q_Web
    ../Q_Sys_Core/Q_Web/: QWebAddrMgt.c QWebApi.c QWebCallBack.c QWebHandler.c QWebName.c QWebPacket.c QWebTransmission.c QWebSession.c
  group Pages
    ../Q_Sys_Core/Pages/: AppListPage.c ChatPage.c EBookPage.c FileListPage.c KeyBoardPage.c MainPage.c MusicPage.c PicturePage.c PinYinForKeyBoardPage.c QWebPage.c SettingsPage.c SnakePage.c TestPage.c TouchCheckPage.c NewsPage.c NumCtrlObjPage.c StrCtrlObjPage.c
