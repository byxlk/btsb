# Keil uVision project btsbapp.uvprojx, settings and files
target BTSBAPP (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F205RCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: btsbapp +hex
  AfterMake: C:\Keil_v521a\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/btsbapp.bin ./Objects/btsbapp.axf
  AfterMake: H:\BluetoothSoundBox\Project_BtSB\Btsb_Vip_Project\Compiler\DelTempFile_CopyHex.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Applications;..\..\Drivers;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\Libraries\CMSIS\Include;..\..\rt-thread\components\finsh;..\..\rt-thread\libcpu\arm\cortex-m3;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\include;..\..\rt-thread\components\CMSIS\Include;..\..\rt-thread\components\dfs\include;..\..\rt-thread\components\dfs\filesystems\elmfat
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    ../../Applications/: application.c startup.c rtconfig.h
  group Finsh
    ../../rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group FileSystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../rt-thread/components/dfs/filesystems/elmfat/option/: cc936.c
  group OS_Kernel
    ../../rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Drivers
    ../../Drivers/: board.c rtc.c serial.c stm32f2xx_it.c usart.c
  group StartUp
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group STM32_CMSIS
    ../../rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group STM32_StdPeriph
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
