# Keil uVision project btsb.uvprojx, settings and files
target STM32F205_BTSB (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F205RETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: btsb +hex
  AfterMake: C:\Keil_v521a\ARM\ARMCC\bin\fromelf.exe --bin -o ../out_btsbapp.bin ./Objects/btsb.axf
  AfterMake: H:\BluetoothSoundBox\Project_BtSB\Btsb_Vip_Project\DelTempFile_CopyHex.bat
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\RTOS\Template;..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\FatFS\src;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\User;..\User\bsp;..\User\emWinTask;..\STemWin\Config;..\STemWin\DisplayDriver;..\STemWin\inc;..\STemWin\OS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group StdPeriph_Driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_crc.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c stm32f2xx_can.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dcmi.c stm32f2xx_fsmc.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_rng.c stm32f2xx_sdio.c stm32f2xx_spi.c
  group StartUp
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group FatFS
    ../FatFS/src/: diskio.c ff.c
    ../FatFS/src/option/: cc936.c
  group STemWin/LCD_Driver
    ../STemWin/DisplayDriver/: GUIDRV_Template.c
  group STemWin/GUI_X
    ../STemWin/OS/: GUI_X_FreeRTOS.c
  group STemWin/GUI_Config
    ../STemWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group STemWin/Lib
    ../STemWin/Lib/: STemWin532_CM3_OS_Keil.lib
  group User
    ../User/: main.c SysInfoTest.c FreeRTOSConfig.h includes.h spi_flash_fatfs.c
  group User/Bsp
    ../User/bsp/: bsp.c bsp_dwt.c bsp_uart_fifo.c bsp_tft_lcd.c bsp_lcd_st7789v.c bsp_tim_pwm.c bsp_cpu_rtc.c bsp_user_lib.c bsp_adc.c bsp_spi_flash.c bsp_key.c
  group User/GUI
    ../User/emWinTask/: App_Language.c MainTask.c MainTask.h App_SysFunction.c Yahei.c App_About.c App_Bluetooth.c App_DateTime.c App_Music.c App_Sleep.c App_HomePage.c Image_Resource.c
  group Doc
    ../Doc/: 03.开发环境说明.txt 01.例程功能说明.txt 02.例程修改记录.txt
